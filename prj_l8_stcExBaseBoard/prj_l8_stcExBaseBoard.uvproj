# Keil uVision project prj_l8_stcExBaseBoard.uvproj, settings and files
target itemMain (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: prj_l8_stcExBaseBoard +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\usrMain
  link misc: REMOVEUNUSED
  group groupMain
    ./usrMain/: usrMain.c STC8xxxx.H Type_def.h STC8G_H_Switch.h
